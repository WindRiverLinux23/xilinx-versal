LINUX-YOCTO_INC_XILINX-VERSAL = ""
LINUX-YOCTO_INC_XILINX-VERSAL:xilinx-versal = "linux-yocto-xilinx-versal.inc"
require ${LINUX-YOCTO_INC_XILINX-VERSAL}

KBRANCH:xilinx-versal  = "v6.1/standard/preempt-rt/sdkv6.1/xlnx-soc"
