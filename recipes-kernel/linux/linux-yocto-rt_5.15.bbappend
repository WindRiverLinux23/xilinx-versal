LINUX-YOCTO_INC_XILINX-VERSAL = ""
LINUX-YOCTO_INC_XILINX-VERSAL:xilinx-versal = "linux-yocto-xilinx-versal.inc"
require ${LINUX-YOCTO_INC_XILINX-VERSAL}

KBRANCH:xilinx-versal  = "v5.15/standard/preempt-rt/sdkv5.15/xlnx-soc"
